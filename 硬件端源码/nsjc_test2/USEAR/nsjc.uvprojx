# Keil uVision project nsjc.uvprojx, settings and files
target nsjc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nsjc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USEAR;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\PERIPHERALS\ADC;..\PERIPHERALS\FSR;..\PERIPHERALS\LED;..\PERIPHERALS\MPU6050\eMPL;..\PERIPHERALS\MPU6050;..\PERIPHERALS\Plusenor;..\PERIPHERALS\READ_DATA;..\CJSON
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_tim.c
  group PERIPHERALS
    ../PERIPHERALS/ADC/: adc.c
    ../PERIPHERALS/FSR/: FSR.c
    ../PERIPHERALS/LED/: led.c
    ../PERIPHERALS/Plusenor/: Plusenor.c
    ../PERIPHERALS/MPU6050/: mpu6050.c mpuiic.c
    ../PERIPHERALS/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../PERIPHERALS/READ_DATA/: Read_Data.c
  group CJSON
    ../CJSON/: cJSON.c
